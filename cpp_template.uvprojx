# Keil uVision project cpp_template.uvprojx, settings and files
target CPP_Test_IOStream (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1100-T038x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.10.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UART_transmit
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: XMC1100_T038x0064,__USE_ANSI_EXAMPLE_RAND
  c misc: --cpp11
  c include: D:\XMC_Peripheral_Library_v2.1.8\XMCLib\inc
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ./: main.cpp xmc1100_it.c led.cpp dbg.c file_descriptor.cpp
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.3.0, Device:Startup 2.4.0, Device:XMClib:GPIO 2.1.22, Device:XMClib:RTC 2.1.22, Device:XMClib:SCU 2.1.22, Device:XMClib:UART 2.1.22, Device:XMClib:VADC 2.1.22, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
